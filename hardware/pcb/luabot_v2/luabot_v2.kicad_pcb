# Repository karolans25/luabot

File README.md:

# LUABOT #

LuaBot es una plataforma que puede ser usada en
robótica, domótica u otros fines donde sea necesario automatizar un proceso y
pueda intervenir la electrónica.
Consta tanto de un hardware y un software, ambos de tipo open source.
LuaBot es pensado como una herramienta que facilita la programación de
tareas que necesiten ser automatizadas y/o tele-operadas incorporando elementos 
básicos para tal fin, además, evita al usuario final la engorrosa tarea de
aprender un lenguaje de programación, haciendo que éste se ocupe principalmente 
del algoritmo a desarrollar.

Tener en cuenta que luabot es desarrollado a partir de varias herramientas opensource 
a las cuales se le deben los créditos.

* [Blockly](https://developers.google.com/blockly/)
* [NodeJS](https://nodejs.org/en/)
* [npm](https://www.npmjs.com/)
* [Apps chrome-chromium](https://developer.chrome.com/apps/first_app)
* [Kicad](http://kicad-pcb.org/)
* [ESP8266](http://www.esp8266.com/)
* [nodeMCU](https://nodemcu.readthedocs.io/en/master/)
* [VIM](http://www.vim.org/)
* [gimp](https://www.gimp.org/)

## Summary ##

* Módulo WiFi: Preparado para soportar IOT (internet de las cosas) 
* Interprete: Se hace uso de uno de los niveles más altos de abstracción en programación, a pesar de que no se pueda hacer
un control mayor sobre el hardware u optimizar recursos, permite que la programación sea más amigable con respecto a otros
paradigmas de programación.
* Programación en Bloques: La fusión entre la programación de bloques y el interprete evita los errores de sintaxis haciendo que solo se ocupe el programador
por la semántica.
* Piense usted mismo: hay herramientas que tienen como eslogan "hágalo usted mismo" o "fácil de hacer"  pero eso no implica
que sepa cómo funciona (copy and paste).
* Flexibilidad: No se rige sobre un sistema operativo en particular, a pesar de que requiera un navegador de internet, se
puede hacer uso de cualquiera que cumpla con los mínimos requerimientos.
* Aplicaciones: Pensado inicialmente para aplicaciones educativas, también puede ser usado para propósitos profesionales,
(como ejemplo un agrónomo que quiera hacer mediciones de comportamiento pero no tiene conocimientos en programación explícitamente)
el único requerimiento es pensar.

## Developers ##

* **Carolina Pulido**, crpulidog@unal.edu.co
* **Johnny Cubides**, jgcubidesc@unal.edu.co

## LuaBot Release ##

* [LuaBot version 1 2016-06-16](https://bitbucket.org/pinguinotux/luabot/downloads/webIDEAppChrome_version_1.zip)
Se ha liberado la primera versión del software, la cual se instala como extensión en el navegador Chrome o Chromium.

## Software ##

El software de LuaBot se presenta en dos alternativas:

1. Como una extensión de google-chrome o extensión para chromium.
2. Como una aplicación cliente-servidor con la ayuda de nodeJS.

### App Google Chrome ###

#### How Install ####

[Vídeo para instalar Luabot como extensión de Chromium o google-chrome](https://youtu.be/Y3NwrFeUX0I)

### web y nodejs ###

Se requiere tres aplicaciones para poder ejecutar luabot con nodeJS.
 
	* nodejs (está en el directorio serverNode)
	* python 2.7 (previamente instalado)
	* navegador web con soporte para HTML5

Uso:
Ejecute el script llamado webNodeJS.

Compruebe que tenga instalado python 2.7 con el modulo python-serial y un navegador de internet.
Además, este script debe estar al nivel de los directorios webIDEnodejs, serverNode, tools-ESP8266 como en este ejemplo:

```
|- webIDENodeJS.sh
|- tools-ESP8266/
|- serverNode/
|- webIDEnodejs/
```
De lo contrario no se ejecutará correctamente.
Por defecto el navegador que se lanzara será Firefox. Si usa 
otro navegador comente y descomente el de su elección.

## Hardware ##

## Agradecimientos ##

**Carlos Iván Camargo Bareño**,
Profesor de Sistemas Embebidos, Facultad De Ingeniería,
Departamento de Ingeniería Eléctrica y Electrónica,
Universidad Nacional De Colombia.

Att: grupo pinguinoTux

## KiCad design hardware/pcb/luabot_v2/luabot_v2.kicad_pcb

File hardware/pcb/luabot_v2/README.md:

## Creación de Logo ##

Se ha usado la imagen logo.png la cual fue arreglada con gimp, para agregar
al proyecto del pcb se debe hacer uso de la herramienta **Bitmap2Componet**
para crear la librería correspondiente al logo. Para ello se ha seleccionado
un DPI y una Resolution ambas de 300, sin inversión y exportada como 
**.kicad_mod**.

Para hacer uso de ella (la imagen) se debe agregar la librería como se hace
habitualmente (manager de librerías), para luego ser llamada como componente
con la herramienta de inserción de los mismos.

## Errores de Diseño ##

Los errores a continuación serán tomados en cuenta en la próxima versión:

* En el esquemático, el regulador 1117 de 3.3 V, el conector más ancho (4)
está conectado a GND lo cual genera un corto en fuente. Por ahora, se está
cortando la base de esa pista para aislar ese punto de conexión.

* La dirección de los puertos de salida deberían estar organizados de manera
descendente (7, 6, 5, 2, 1, 0) pero el 1 y el 2 están invertidos, para éste
diseño se cambió la capa de serigrafía para no tener que reconstruir el pcb.
La corrección consiste en corregir el esquemático y recrear el pcb.

* Cambiar los puntos de unión que quedan en el lugar del esp8266, ya que
ésto inestabiliza y dificulta la soldada del esp en la tarjeta.

Nota: En la creación de las tarjetas no han quedado debidamente separados
los caminos de los pads de conexión de salida, se debe verificar con 
rigurosidad el estado de los mismos, ya que pueden quemar las salidas del
esp8266.

Board: 2 copper layers, 67.8 x 32.1 mm, 21 parts (0 on the bottom side), 21 nets.

Parts:
3.3V: jump 3.3v or 5v; pin_socket_3
5V_USB: uart; pin_socket_4
5V_USB#2: jump_power_source; pin_socket_3
ADC: salidas_GPIO; pin_socket_7
C1, C2: 330µF; C1V7
C3: 100pF; C1
CON1: BAT_IN; JACK_ALIM
FLASH: JUMPER; pin_socket_2
P2: GND_GPIO; pin_socket_7
P3: VCC_GPIO; pin_socket_7
R1, R2, R3, R4, R5: 10k; R3
R6: 100k; R3
R7: 220k; R3
SW1: RESET; SW_PUSH_SMALL
U1: ESP-07V2; ESP-07v2
U2: LM1117; SOT223

Connections:
+3.3V: 3.3V.3, C1.1, C3.1, R1.2, R2.2, R4.2, R5.2, U1.8, U2.2
+5V: 3.3V.1, 5V_USB#2.2, C2.1, U2.3
+5V_CARGADOR: 5V_USB#2.3, CON1.1
+5V_USB: 5V_USB.4, 5V_USB#2.1
ADC: R6.1, R7.2, U1.2
ADC_EX: ADC.7, R7.1
CH_PD: R2.1, U1.3
D0: ADC.1, U1.4
D1: ADC.2, U1.13
D2: ADC.3, U1.14
D5: ADC.4, U1.5
D6: ADC.5, U1.6
D7: ADC.6, U1.7
FLASH: FLASH.2, R1.1, U1.12
GND: 5V_USB.1, C1.2, C2.2, C3.2, CON1.2, CON1.3, FLASH.1, P2.1, P2.2, P2.3, P2.4, P2.5, P2.6, P2.7, R3.2, R6.2, SW1.2, U1.9, U2.1, U2.4
unnamed: 3.3V.2, P3.1, P3.2, P3.3, P3.4, P3.5, P3.6, P3.7
O02: R5.1, U1.11
O15: R3.1, U1.10
RX: 5V_USB.3, U1.15
Reset: R4.1, SW1.1, U1.1
TX: 5V_USB.2, U1.16

## KiCad design hardware/pcb/switchPower/switchPower.kicad_pcb

File hardware/README.md:

Fuente, montaje de prueba esp8266 12e

http://thinkingparts.blogspot.com.co/2015/08/home-automation-uploading-code-into.html

http://thinkingparts.blogspot.com.co/2015_08_01_archive.html

http://thinkingparts.blogspot.com.co/2015_05_01_archive.html

Parts:
1N4004: DIODE
K0: CONN_3
NPN1: 2N2222
NPN2: 2N2222A
P2, P3, P4: CONN_2
R1: 10K
R2: 30k
RLY5: RELAY_5PINS

Connections:
GND: K0.3, NPN1.1 (E), NPN2.1 (E)
IN: K0.1, R1.1, R2.1
unnamed: P2.1, P3.2 (PM)
unnamed: NPN2.3 (C), P4.2 (PM)
unnamed: NPN2.2 (B), R2.2
unnamed: NPN1.2 (B), R1.2
unnamed: P2.2 (PM), RLY5.1
unnamed: P3.1, RLY5.3
unnamed: 1N4004.1 (A), NPN1.3 (C), RLY5.2
VCC: 1N4004.2 (K), K0.2 (PM), P4.1, RLY5.5

Board: 2 copper layers, 42.1 x 34.9 mm, 10 parts (0 on the bottom side), 10 nets.

## KiCad design hardware/pcb/luabot_v1/luabot_v1.kicad_pcb

Parts:
C1, C2: 330µF
C3: 100pF
CON1: bat_in
JP1: jump_power_source
JP2: JUMPER
JP3: jump 3.3v or 5v
P1: ext_izq_GPIO
P2: ext_der_GPIO
P3: uart
P5: (GND,VCC)_GPIO
P6: salidas_GPIO
R1, R2, R3, R4, R5: 10k
R6: 100k
R7: 220k
SW1: SW_PUSH_SMALL
U1: ESP-07V2
U2: LM1117-3.3V

Connections:
+3.3V: C1.1, C3.1, JP3.3, P1.8, R1.2, R2.2, R4.2, R5.2, U1.8, U2.2 (VOUT)
+5V: C2.1, JP1.2, JP3.1, P2.8, U2.3 (VIN)
+5V_CARGADOR: CON1.1, JP1.3
+5V_USB: JP1.1, P3.4
ADC: P1.2, R6.1, R7.2, U1.2
ADC_EX: P6.7, R7.1
CH_PD: P1.3, R2.1, U1.3
D0: P1.4, P6.1, U1.4
D1: P2.4, P6.2, U1.13
D2: P2.3, P6.3, U1.14
D5: P1.5, P6.4, U1.5
D6: P1.6, P6.5, U1.6
D7: P1.7, P6.6, U1.7
FLASH: JP2.2, P2.5, R1.1, U1.12
GND: C1.2, C2.2, C3.2, CON1.2, CON1.3, JP2.1, P1.9, P2.9, P3.1, P5.1, P5.3, P5.5, P5.7, P5.9, P5.11, P5.13, R3.2, R6.2, SW1.2, U1.9, U2.1 (GND), U2.4 (TAB)
unnamed: JP3.2, P5.2, P5.4, P5.6, P5.8, P5.10, P5.12, P5.14
O02: P2.6, R5.1, U1.11
O15: P2.7, R3.1, U1.10
RX: P2.2, P3.3, U1.15
Reset: P1.1, R4.1, SW1.1, U1.1
TX: P2.1, P3.2, U1.16

Board: 2 copper layers, 22 parts (0 on the bottom side), 21 nets, no tracks yet.

## Commit log

2015-12-12 Inicio de proyecto: tarjeta embebida
2015-12-12 Documentación web para nodeMcu(esp8266 con lua)
2015-12-12 Agregando Manual Lua en español
2015-12-12 Documentación para la tarjeta a desarrollar
2015-12-13 Master firmware lua
2015-12-20 Organizando directorios
2016-01-03 Esqueleto terminado de luabot
2016-01-06 Creación de script para ejecuación de luabot con nodejs
2016-01-06 actalización del fichero README.md
2016-01-06 cambios menores en scrip webIDENodeJS.sh
2016-01-07 Inicio de app para chrome:LuaBot app
2016-01-13 Timer module
2016-01-13 servidor para 64 bits
    Changes to be committed:
    modified: serverNode/init.lua
    //Archivo de prueba
    new directory: serverNode/node-v5.4.1-linux-x64/*
    //Para realizar la conexión con OS de 64-bit
    /*
2016-01-14 IDE funcionando en app-chrome, sin embargo,aún no hace operaciones seriales
2016-01-15 nada importante
2016-01-15 Corrección manual por mezclas.
2016-01-18 Documentacion realizada sobre app luaBot, Soporte para comunicación Serial
2016-01-18 Temporizador funcionando correctamente
2016-01-18 Módulo PWM listo para probar
2016-01-18 nodemcu-uploader.py
    Revisar el archivo nodemcu-uploader.py.
    Está muy completo: ./nodemcu-uploader.py -h
    upload
    exec
    download
    file
2016-01-20 Moviendo el nodemcu-uploader.py a tools-ESP8266
2016-01-22 Prueba1 para soporte en windows
2016-01-22 Sólo moví LuaBot.bat de carpeta a serverNode
2016-01-22 Soporte de serial_port para app chrome, la función run (ejecutar achivos en el interprete) ya está soportada, sin embargo, aún debe pasar más pruebas
2016-01-22 Agregando nodeMCU-Tool para nodejs
2016-01-22 Documentacion para node serial port, nodemcu
2016-01-26 webIdeNodejs guarda y carga proyectos, nodejs tiene soporte nodemcu para serial port, webIDEApp carga y guarda proyectos, tiene soporte para puerto serial
2016-01-26 Manejo de mensajes de retorno
2016-01-26 README.md edited online with Bitbucket
2016-01-27 Listando puertos_seriales
    *Ahora se puede seleccionar el puerto serial a usar para la
    comunicación con el ESP8266.
    * Se quitó en nodejs el selector de varios idiomas.
    * Se quitó los (;) opcionales en node lua para optimizar memoria
    * Ahora los botones tienen eventos onMouseOver que muestran el título
    de éstos (comentarios indicativos).
2016-01-28 Se ha agregado funciones especiales.
    * Consiste en opciones como node.restart(), dofile, fileformat.
2016-01-29 Creando primera versión de pcb luabot
2016-01-29 Agregando librerías para esp8266 -e7v2 en kickad
    No olvidar agregarlas en su directorio local de kickad
    de forma relativa
2016-02-01 Serial port para linux 64 bits
2016-02-02 cambios del timer y pwm
2016-02-03 agregando condicionamiento de condicionamiento digital
2016-02-04 avance hadware y librerias footprint
2016-02-04 Arreglo de webIDENodeJS.sh
2016-02-05 Serial Port aumento de velocidad
    Se ha mejorado el rendimiento en el envío y la recepción de datos
    por el puerto serial para el app de chrome
2016-02-05 avance hadware layout
2016-02-05 Borrado de archivos innecesarios
2016-02-05 Agregando script
2016-02-05 Listo para probar el adc y el pwm
2016-02-05 Actualización de módulos pwm y gpio del AppChrome
2016-02-05 avance hadware tarjeta terminada
2016-02-05 Agregando íconos a la barra de herramientas
2016-02-05 borrando luabot_v1
2016-02-06 Falta capturar la dirección ip de la stacion. Terminado y probado el pwm y el adc.
2016-02-06 avance switchporwer esquematico
2016-02-06 librerias y footprints componentes
2016-02-06 avance switchpower
2016-02-09 Archivos ejemplo para adc, rgb, blink y wifi
2016-02-10 avance modulo portencia
2016-02-12 Creada carpeta: planDeEstudio
2016-02-26 Presentación y proyectos de Fritzing
2016-02-26 Costos trajeta y kit
2016-03-03 Preparando iconos para appChrome
2016-03-03 creando cuestinoario 1
2016-03-03 Cuestionario #1
2016-03-03 Corregido
2016-03-04 Imágenes
2016-03-04 avance guia 2
2016-03-07 organizando repositorio
2016-03-07 Clase 2
2016-03-11 Guias adelantadas
2016-03-11 borrando video del transistor
2016-03-18 Clase 4
2016-03-20 inicio de documento tesis_luaBot
2016-03-20 avance de documento
2016-03-21 avance
2016-03-21 avance luabot: lenguajes de programación
2016-03-21 avance1
2016-04-01 Guia 4o5
    Creación de la guia 4 o 5
2016-04-01 Se ordenó la carpeta del plan de estudio
2016-04-01 guia 4 o 5 avance
2016-04-01 adición guia 1
2016-04-01 Agregando tarea1 sobre uso correcto de protoboard
2016-04-01 corrigiendo cuestionario 1
2016-04-01 tarea2 y actualización de Cronograma
2016-04-01 Reporte de lo que falta
2016-04-01 Circuitos digitales trabajados
2016-04-01 Clase 5
2016-04-08 Falta hacer la guía y la presentación
2016-04-18 Clase6
2016-04-20 Agregando clase7
2016-04-22 Clase 8
2016-05-08 arreglando hardware, finalizando muestras
2016-05-10 pseint
2016-05-20 Costos y modificaciones menores para finaluzar producto
2016-05-21 Tarjeta
2016-05-21 plot hardware pcb
2016-05-23 Actualización de las máscaras para el hardware versión1
2016-05-23 Actualización PCB luabot_v2
2016-05-23 Agregando programas hechos con luabot para pruebas
2016-05-23 cambios menores
2016-05-27 Agregando tema
2016-06-13 Creando Imangen para ESP
2016-06-13 Imagen esp8266 luabot
2016-06-13 Temporizador y ADC
2016-06-16 agregando image
2016-06-16 arreglando el README
2016-06-16 Agregando trabajos presentados por estudiantes
2016-06-16 Ajustes Readme
2016-06-17 ajustes al README
2016-06-20 Carpeta proyecto profesor Camargo
2016-06-20 nuevo repo
2016-06-21 creando directorios para dataSheet
2016-06-21 Restablecimiento de la prueba enceder led
2016-06-22 prueba ejemplo puente h
2016-06-22 Arreglos del demo y de puenteH
2016-06-24 Inicia soporte para android
2016-06-30 Agregando modulos al IDE + soporte android
2016-07-27 Agregando ejemplos
2016-08-15 android
2016-08-15 Adelantos
2016-08-29 Limpiando módulos
2016-09-11 Cambio de velocidad 115200 baud serialport
    Al parecer el pl2303X está siendo sustituido por el
    HL-340, ambos son conversores usb a uart de nivel lógico ttl-usb.
    Se hizo una modificación en el archivo webIDEAppChrome/app/action.js
    para que el archivo init.lua en el nodemcu contenga en su primera línea
    el cambio de velocidad de 9600 a 115200 baudios.
    Se ha conservado el anterior archivo action.js como actionInitTo9600.js
2016-10-01 Soporte de LUABOT para DHT
2016-10-01 borrando innecesario archivo
2016-10-01 pruebas luabot
2016-10-23 agregando soporte internet de las cosas
2016-11-05 actulización importane para la autonomía de la tajeta
2016-11-05 Arreglo para que gpio0 sea un entrada y no dañe sensores como por ejemplo DHT11
2017-04-27 borrando comprimido innecesario
